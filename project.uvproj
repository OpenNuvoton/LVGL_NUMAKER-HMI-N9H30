# Keil uVision project project.uvproj, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: rtthread
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --c99
  c include: applications;.;board;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\nogcc;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\arm926;rt-thread\components\drivers\audio;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\drivers\touch;rt-thread\components\drivers\include;rt-thread\components\drivers\include;libraries\n9h30\rtt_port;packages\fal-latest\inc;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\finsh;.;rt-thread\include;libraries\n9h30\Driver\Include;packages\LVGL-v8.1.0\src;packages\LVGL-v8.1.0\src\core;packages\LVGL-v8.1.0\src\draw;packages\LVGL-v8.1.0\src\extra;packages\LVGL-v8.1.0\src\font;packages\LVGL-v8.1.0\src\gpu;packages\LVGL-v8.1.0\src\hal;packages\LVGL-v8.1.0\src\misc;packages\LVGL-v8.1.0\src\widgets;packages\LVGL-v8.1.0\src\extra\layouts;packages\LVGL-v8.1.0\src\extra\libs;packages\LVGL-v8.1.0\src\extra\others;packages\LVGL-v8.1.0\src\extra\themes;packages\LVGL-v8.1.0\src\extra\widgets;packages\LVGL-v8.1.0\src\extra\layouts\flex;packages\LVGL-v8.1.0\src\extra\layouts\grid;packages\LVGL-v8.1.0\src\extra\libs\bmp;packages\LVGL-v8.1.0\src\extra\libs\freetype;packages\LVGL-v8.1.0\src\extra\libs\fsdrv;packages\LVGL-v8.1.0\src\extra\libs\gif;packages\LVGL-v8.1.0\src\extra\libs\png;packages\LVGL-v8.1.0\src\extra\libs\qrcode;packages\LVGL-v8.1.0\src\extra\libs\rlottie;packages\LVGL-v8.1.0\src\extra\libs\sjpg;packages\LVGL-v8.1.0\src\extra\others\snapshot;packages\LVGL-v8.1.0\src\extra\themes\basic;packages\LVGL-v8.1.0\src\extra\themes\default;packages\LVGL-v8.1.0\src\extra\themes\mono;packages\LVGL-v8.1.0\src\extra\widgets\animimg;packages\LVGL-v8.1.0\src\extra\widgets\calendar;packages\LVGL-v8.1.0\src\extra\widgets\chart;packages\LVGL-v8.1.0\src\extra\widgets\colorwheel;packages\LVGL-v8.1.0\src\extra\widgets\imgbtn;packages\LVGL-v8.1.0\src\extra\widgets\keyboard;packages\LVGL-v8.1.0\src\extra\widgets\led;packages\LVGL-v8.1.0\src\extra\widgets\list;packages\LVGL-v8.1.0\src\extra\widgets\meter;packages\LVGL-v8.1.0\src\extra\widgets\msgbox;packages\LVGL-v8.1.0\src\extra\widgets\span;packages\LVGL-v8.1.0\src\extra\widgets\spinbox;packages\LVGL-v8.1.0\src\extra\widgets\spinner;packages\LVGL-v8.1.0\src\extra\widgets\tabview;packages\LVGL-v8.1.0\src\extra\widgets\tileview;packages\LVGL-v8.1.0\src\extra\widgets\win;packages\LVGL-v8.1.0\src\gpu\sdl;applications\lvgl;packages\LVGL-v8.1.0\rt-thread;rt-thread\components\net\lwip-2.0.2\src;rt-thread\components\net\lwip-2.0.2\src\include;rt-thread\components\net\lwip-2.0.2\src\include\ipv4;rt-thread\components\net\lwip-2.0.2\src\arch\include;rt-thread\components\net\lwip-2.0.2\src\include\netif;libraries\nu_packages\NuUtils\inc;rt-thread\components\libc\posix\io;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\ipc;packages\ramdisk-latest\inc;rt-thread\components\drivers\usb\usbdevice;rt-thread\components\drivers\usb\usbhost;rt-thread\components\drivers\usb\usbhost\class;rt-thread\components\drivers\usb\usbhost\core;rt-thread\components\drivers\usb\usbhost\include;rt-thread\components\drivers\include;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\socket\sys_socket;rt-thread\components\utilities\utest
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: .\linking_scripts\n9h30.sct
  group Applications
    applications/: mnt.c main.c
  group board
    board/: board_dev.c nu_pin_init.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscalls.c libc_syms.c syscall_mem.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c showmem.c div0.c
    rt-thread/libcpu/arm/arm926/: machine.c mmu.c context_rvds.S trap.c stack.c start_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/audio/: audio_pipe.c audio.c
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: adc.c rt_drv_pwm.c pin.c rt_inputcapture.c
    rt-thread/components/drivers/rtc/: rtc.c alarm.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    rt-thread/components/drivers/src/: completion.c ringbuffer.c workqueue.c waitqueue.c dataqueue.c pipe.c ringblk_buf.c
    rt-thread/components/drivers/touch/: touch.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    libraries/n9h30/rtt_port/: drv_sdh.c drv_etimer.c drv_adc.c drv_rtc.c drv_wdt.c drv_usbd.c drv_scuart.c drv_softi2c.c drv_jpegcodec.c drv_common.c drv_emac.c drv_usbhost.c drv_vpost.c drv_pwm.c drv_systick.c drv_i2c.c drv_sys.c drv_can.c drv_etimer_capture.c drv_ge2d.c drv_adc_touch.c drv_qspi.c drv_timer.c drv_i2s.c drv_uart.c drv_crypto.c drv_gpio.c
  group fal
    packages/fal-latest/src/: fal_rtt.c fal_flash.c fal.c fal_partition.c
    packages/fal-latest/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    rt-thread/src/: object.c mempool.c mem.c ipc.c irq.c device.c scheduler.c clock.c memheap.c idle.c thread.c timer.c components.c kservice.c signal.c
  group Libraries
    libraries/n9h30/Driver/Source/: nu_crypto.c nu_wdt.c nu_i2s.c nu_etimer.c nu_spi.c nu_uart.c nu_emac.c nu_can.c nu_gpio.c nu_wwdt.c nu_sdh.c nu_usbd.c nu_cap.c nu_pwm.c nu_timer.c nu_sys.c nu_rtc.c nu_scuart.c nu_lcd.c nu_fmi.c
  group LVGL
    packages/LVGL-v8.1.0/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.1.0/src/font/: lv_font_montserrat_22.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_12_subpx.c lv_font_montserrat_42.c lv_font_montserrat_32.c lv_font_loader.c lv_font_montserrat_20.c lv_font_unscii_16.c lv_font_montserrat_8.c lv_font_montserrat_28.c lv_font_fmt_txt.c lv_font_montserrat_12.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_10.c lv_font_montserrat_40.c lv_font_montserrat_36.c lv_font_montserrat_14.c lv_font_montserrat_30.c lv_font_montserrat_24.c lv_font_montserrat_34.c lv_font.c lv_font_montserrat_38.c lv_font_unscii_8.c lv_font_simsun_16_cjk.c lv_font_montserrat_48.c lv_font_montserrat_46.c lv_font_montserrat_26.c lv_font_montserrat_44.c lv_font_montserrat_28_compressed.c
    packages/LVGL-v8.1.0/src/core/: lv_disp.c lv_theme.c lv_obj_pos.c lv_obj_style.c lv_event.c lv_obj_style_gen.c lv_obj_scroll.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_group.c lv_refr.c lv_obj_tree.c
    packages/LVGL-v8.1.0/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.1.0/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LVGL-v8.1.0/src/widgets/: lv_line.c lv_checkbox.c lv_objx_templ.c lv_roller.c lv_btnmatrix.c lv_bar.c lv_textarea.c lv_dropdown.c lv_slider.c lv_img.c lv_table.c lv_canvas.c lv_label.c lv_arc.c lv_btn.c lv_switch.c
    packages/LVGL-v8.1.0/src/gpu/sdl/: lv_gpu_sdl_draw_blend.c lv_gpu_sdl_lru.c lv_gpu_sdl_texture_cache.c lv_gpu_sdl_draw_arc.c lv_gpu_sdl_draw_label.c lv_gpu_sdl_draw_line.c lv_gpu_sdl_stack_blur.c lv_gpu_sdl_draw_rect.c lv_gpu_sdl_draw_img.c lv_gpu_sdl_mask.c lv_gpu_sdl_utils.c
    packages/LVGL-v8.1.0/src/extra/libs/png/: lv_png.c lodepng.c
    packages/LVGL-v8.1.0/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.1.0/src/misc/: lv_fs.c lv_mem.c lv_txt_ap.c lv_area.c lv_style_gen.c lv_utils.c lv_gc.c lv_anim_timeline.c lv_templ.c lv_ll.c lv_log.c lv_color.c lv_bidi.c lv_timer.c lv_tlsf.c lv_math.c lv_txt.c lv_anim.c lv_style.c lv_printf.c lv_async.c
    packages/LVGL-v8.1.0/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.1.0/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.1.0/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.1.0/src/draw/: lv_draw_img.c lv_draw_rect.c lv_img_decoder.c lv_draw_triangle.c lv_draw_arc.c lv_img_cache.c lv_draw_line.c lv_draw_label.c lv_draw_mask.c lv_draw_blend.c lv_img_buf.c
    packages/LVGL-v8.1.0/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.1.0/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.1.0/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.1.0/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    packages/LVGL-v8.1.0/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.1.0/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.1.0/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.1.0/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.1.0/src/gpu/: lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_sdl.c lv_gpu_stm32_dma2d.c lv_gpu_nxp_pxp.c
    packages/LVGL-v8.1.0/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.1.0/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-v8.1.0/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.1.0/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.1.0/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_stdio.c lv_fs_win32.c lv_fs_posix.c
    packages/LVGL-v8.1.0/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.1.0/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.1.0/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.1.0/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.1.0/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.1.0/src/extra/: lv_extra.c
    packages/LVGL-v8.1.0/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.1.0/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.1.0/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.1.0/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.1.0/src/extra/widgets/imgbtn/: lv_imgbtn.c
  group LVGL-demo
    packages/lv_music_demo-v0.1.1/assets/: img_lv_demo_rtt_music_btn_prev.c img_lv_demo_rtt_music_wave_top.c img_lv_demo_rtt_music_slider_knob.c img_lv_demo_rtt_music_icon_3.c img_lv_demo_rtt_music_icon_4.c img_lv_demo_rtt_music_cover_1.c img_lv_demo_rtt_music_btn_pause.c img_lv_demo_rtt_music_list_border.c img_lv_demo_rtt_music_icon_2.c img_lv_demo_rtt_music_btn_list_play.c img_lv_demo_rtt_music_corner_left.c img_lv_demo_rtt_music_btn_play.c img_lv_demo_rtt_music_btn_next.c img_lv_demo_rtt_music_logo.c img_lv_demo_rtt_music_wave_bottom.c img_lv_demo_rtt_music_cover_2.c img_lv_demo_rtt_music_btn_loop.c img_lv_demo_rtt_music_btn_list_pause.c img_lv_demo_rtt_music_icon_1.c img_lv_demo_rtt_music_btn_rnd.c img_lv_demo_rtt_music_corner_right.c img_lv_demo_rtt_music_cover_3.c
    packages/lv_music_demo-v0.1.1/: lv_demo_rtt_music.c lv_demo_rtt_music_list.c lv_demo_rtt_music_main.c
  group LVGL-port
    applications/lvgl/: lv_demo.c lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.1.0/rt-thread/: lv_rt_thread_port.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c
    rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
    rt-thread/components/net/lwip-2.0.2/src/core/: ip.c netif.c sys.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c tcp_in.c dns.c timeouts.c udp.c pbuf.c def.c tcp.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
  group POSIX
    rt-thread/components/libc/posix/io/: select.c
    rt-thread/components/libc/posix/io/poll/: poll.c
  group ramdisk
    packages/ramdisk-latest/src/: drv_ramdisk.c
  group rt_usbd
    rt-thread/components/drivers/usb/usbdevice/class/: cdc_vcom.c mstorage.c
    rt-thread/components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
  group rt_usbh
    rt-thread/components/drivers/usb/usbhost/class/: udisk.c mass.c
    rt-thread/components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
  group UTest
    rt-thread/components/utilities/utest/: utest.c
